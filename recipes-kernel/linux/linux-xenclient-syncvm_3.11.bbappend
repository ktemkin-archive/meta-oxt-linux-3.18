#Hack: don't build 3.11
COMPATIBLE_MACHINE = "(none)"
