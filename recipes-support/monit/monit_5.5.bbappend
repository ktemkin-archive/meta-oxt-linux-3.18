
#Use the local monitrc, not the one from xenclient-oe.
FILESEXTRAPATHS_prepend := "${THISDIR}:"
